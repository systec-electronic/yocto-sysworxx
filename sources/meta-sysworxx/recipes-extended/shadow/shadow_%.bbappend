RDEPENDS:${PN} = "bash"

FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
