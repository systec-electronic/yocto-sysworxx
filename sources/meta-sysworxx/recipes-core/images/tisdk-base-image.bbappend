IMAGE_INSTALL += "\
    bash-completion \
    htop \
    vim \
"
