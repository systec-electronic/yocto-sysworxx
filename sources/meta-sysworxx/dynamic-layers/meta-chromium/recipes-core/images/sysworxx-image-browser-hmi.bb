require recipes-core/images/sysworxx-image-default.bb

IMAGE_INSTALL:append = "\
    browser-hmi \
"
