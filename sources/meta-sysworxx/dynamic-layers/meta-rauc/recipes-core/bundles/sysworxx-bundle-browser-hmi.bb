require sysworxx-bundle-default.bb

ROOTFS_IMAGE = "sysworxx-image-browser-hmi"
