SYSTEMD_AUTO_ENABLE:${PN}:sysworxx = "disable"
