# Recipe created by recipetool
# This is the basis of a recipe and may need further editing in order to be fully functional.
# (Feel free to remove these comments when editing.)

SUMMARY = "Low-code programming for event-driven applications"
HOMEPAGE = "https://nodered.org"
# WARNING: the following LICENSE and LIC_FILES_CHKSUM values are best guesses - it is
# your responsibility to verify that the values are complete and correct.
#
# The following license files were not able to be identified and are
# represented as "Unknown" below, you will need to check them yourself:
#   node_modules/@node-red/editor-client/public/vendor/ace/LICENSE
#   node_modules/@node-red/editor-client/public/vendor/monaco/dist/css.worker.js.LICENSE.txt
#   node_modules/@node-red/editor-client/public/vendor/monaco/dist/editor.js.LICENSE.txt
#   node_modules/@node-red/editor-client/public/vendor/monaco/dist/html.worker.js.LICENSE.txt
#   node_modules/@node-red/editor-client/public/vendor/monaco/dist/json.worker.js.LICENSE.txt
#   node_modules/@node-red/editor-client/public/vendor/monaco/dist/ts.worker.js.LICENSE.txt
#   node_modules/abbrev/LICENSE
#   node_modules/argparse/LICENSE
#   node_modules/bcryptjs/LICENSE
#   node_modules/bl/LICENSE.md
#   node_modules/cheerio-select/LICENSE
#   node_modules/chownr/LICENSE.md
#   node_modules/colors/MIT-LICENSE.txt
#   node_modules/concat-stream/node_modules/readable-stream/LICENSE
#   node_modules/css-select/LICENSE
#   node_modules/css-what/LICENSE
#   node_modules/domelementtype/LICENSE
#   node_modules/domhandler/LICENSE
#   node_modules/domutils/LICENSE
#   node_modules/entities/LICENSE
#   node_modules/fast-uri/LICENSE
#   node_modules/jackspeak/LICENSE.md
#   node_modules/lodash.clonedeep/LICENSE
#   node_modules/minizlib/LICENSE
#   node_modules/mqtt-packet/LICENSE.md
#   node_modules/mqtt/LICENSE.md
#   node_modules/multer/node_modules/readable-stream/LICENSE
#   node_modules/multer/node_modules/string_decoder/LICENSE
#   node_modules/nth-check/LICENSE
#   node_modules/package-json-from-dist/LICENSE.md
#   node_modules/readable-stream/LICENSE
#   node_modules/sax/LICENSE
#   node_modules/string_decoder/LICENSE
#   node_modules/tar/node_modules/yallist/LICENSE.md
#   node_modules/tough-cookie/LICENSE
#   node_modules/typedarray/LICENSE
#
# NOTE: multiple licenses have been detected; they have been separated with &
# in the LICENSE value for now since it is a reasonable assumption that all
# of the licenses apply. If instead there is a choice between the multiple
# licenses then you should change the value to separate the licenses with |
# instead of &. If there is any doubt, check the accompanying documentation
# to determine which situation is applicable.
LICENSE = "0BSD & Apache-2.0 & BlueOak-1.0.0 & BSD-2-Clause & BSD-3-Clause & ISC & MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=014f1a23c3da49aa929b21a96808ab22 \
                    file://node_modules/@babel/runtime/LICENSE;md5=b1d0cd283a346e919abb3beeb018279d \
                    file://node_modules/@isaacs/cliui/LICENSE.txt;md5=83623193d3051ca8068a89a455c699ca \
                    file://node_modules/@isaacs/cliui/node_modules/ansi-regex/license;md5=d5f2a6dd0192dcc7c833e50bb9017337 \
                    file://node_modules/@isaacs/cliui/node_modules/strip-ansi/license;md5=d5f2a6dd0192dcc7c833e50bb9017337 \
                    file://node_modules/@isaacs/fs-minipass/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/@node-red/editor-api/LICENSE;md5=014f1a23c3da49aa929b21a96808ab22 \
                    file://node_modules/@node-red/editor-client/LICENSE;md5=014f1a23c3da49aa929b21a96808ab22 \
                    file://node_modules/@node-red/editor-client/public/vendor/ace/LICENSE;md5=794d11c5219c59c9efa2487c2b4066b2 \
                    file://node_modules/@node-red/editor-client/public/vendor/monaco/dist/LICENSE;md5=f54bb2c6fe5e92709d134914191197a3 \
                    file://node_modules/@node-red/editor-client/public/vendor/monaco/dist/css.worker.js.LICENSE.txt;md5=571b7e6f18e2556b6eb9b304c98a86c2 \
                    file://node_modules/@node-red/editor-client/public/vendor/monaco/dist/editor.js.LICENSE.txt;md5=b24b1cadad291abac43c27c26690fc71 \
                    file://node_modules/@node-red/editor-client/public/vendor/monaco/dist/html.worker.js.LICENSE.txt;md5=571b7e6f18e2556b6eb9b304c98a86c2 \
                    file://node_modules/@node-red/editor-client/public/vendor/monaco/dist/json.worker.js.LICENSE.txt;md5=571b7e6f18e2556b6eb9b304c98a86c2 \
                    file://node_modules/@node-red/editor-client/public/vendor/monaco/dist/theme/LICENSE;md5=280545e7ad0c4af4a6c0e737934a23b2 \
                    file://node_modules/@node-red/editor-client/public/vendor/monaco/dist/ts.worker.js.LICENSE.txt;md5=7ec01595672f75e83fd81b41f132f4c1 \
                    file://node_modules/@node-red/nodes/LICENSE;md5=014f1a23c3da49aa929b21a96808ab22 \
                    file://node_modules/@node-red/registry/LICENSE;md5=014f1a23c3da49aa929b21a96808ab22 \
                    file://node_modules/@node-red/runtime/LICENSE;md5=014f1a23c3da49aa929b21a96808ab22 \
                    file://node_modules/@node-red/util/LICENSE;md5=014f1a23c3da49aa929b21a96808ab22 \
                    file://node_modules/@node-rs/bcrypt/LICENSE;md5=4a11fa8d408bb2139595ca1242427211 \
                    file://node_modules/@node-rs/bcrypt/LICENSE.rust-bcrypt;md5=1f2942ef647b60da2875b32efa369b9a \
                    file://node_modules/@pkgjs/parseargs/LICENSE;md5=86d3f3a95c324c9479bd8986968f4327 \
                    file://node_modules/@sindresorhus/is/license;md5=d5f2a6dd0192dcc7c833e50bb9017337 \
                    file://node_modules/@szmarczak/http-timer/LICENSE;md5=78fd36a7284eb85369521bcb6e863186 \
                    file://node_modules/@types/http-cache-semantics/LICENSE;md5=d4a904ca135bb7bc912156fee12726f0 \
                    file://node_modules/@types/node/LICENSE;md5=d4a904ca135bb7bc912156fee12726f0 \
                    file://node_modules/@types/readable-stream/LICENSE;md5=d4a904ca135bb7bc912156fee12726f0 \
                    file://node_modules/@types/ws/LICENSE;md5=d4a904ca135bb7bc912156fee12726f0 \
                    file://node_modules/abbrev/LICENSE;md5=e9c0b639498fbe60d17b10099aba77c0 \
                    file://node_modules/abort-controller/LICENSE;md5=86a65c5c19c672ee4cd52492495f1d16 \
                    file://node_modules/accepts/LICENSE;md5=bf1f9ad1e2e1d507aef4883fff7103de \
                    file://node_modules/acorn-walk/LICENSE;md5=33e8b86a084578431a31c72608f226b8 \
                    file://node_modules/acorn/LICENSE;md5=6e381572c3ee395547475a1464db5060 \
                    file://node_modules/agent-base/node_modules/debug/LICENSE;md5=d85a365580888e9ee0a01fb53e8e9bf0 \
                    file://node_modules/agent-base/node_modules/ms/license.md;md5=2b8bc52ae6b7ba58e1629deabd53986f \
                    file://node_modules/ajv/LICENSE;md5=5ed8db7ae36f56c8a5cfc218c41ac926 \
                    file://node_modules/ansi-colors/LICENSE;md5=442b5b961878bc805832d1d24572f62d \
                    file://node_modules/ansi-regex/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/ansi-styles/license;md5=d5f2a6dd0192dcc7c833e50bb9017337 \
                    file://node_modules/append-field/LICENSE;md5=5c090f9df283eefdcea00b2f0766ca6c \
                    file://node_modules/argparse/LICENSE;md5=203a6dbc802ee896020a47161e759642 \
                    file://node_modules/array-flatten/LICENSE;md5=44088ba57cb871a58add36ce51b8de08 \
                    file://node_modules/async-mutex/LICENSE;md5=2bed63242f12f0617c19f2f6ceafab6f \
                    file://node_modules/asynckit/LICENSE;md5=177bc287fb9558bf3ea50b440c1c86ff \
                    file://node_modules/axios/LICENSE;md5=a9f12edf7bc60d718b6ff862f62b3f1a \
                    file://node_modules/balanced-match/LICENSE.md;md5=7fa99ddc3424107350ca6e9a24552085 \
                    file://node_modules/base64-js/LICENSE;md5=ea9187ca93cdc4f71219d1675712e908 \
                    file://node_modules/basic-auth/LICENSE;md5=42fffe6fe0b70501d52150ebb52113df \
                    file://node_modules/bcryptjs/LICENSE;md5=d99a4f4253fea793a1256aef626aa6e5 \
                    file://node_modules/bl/LICENSE.md;md5=455bc3781a009cf9a615e8622138814c \
                    file://node_modules/body-parser/LICENSE;md5=0afd201e48c7d095454eed4ac1184e40 \
                    file://node_modules/body-parser/node_modules/iconv-lite/LICENSE;md5=f942263d98f0d75e0e0101884e86261d \
                    file://node_modules/body-parser/node_modules/raw-body/LICENSE;md5=f22163d3bc6b4bc1bbbdf654fe30af5b \
                    file://node_modules/brace-expansion/LICENSE;md5=a5df515ef062cc3affd8c0ae59c059ec \
                    file://node_modules/buffer-from/LICENSE;md5=46513463e8f7d9eb671a243f0083b2c6 \
                    file://node_modules/buffer/LICENSE;md5=e49e579dbcc02cf1f699deec85fd96f0 \
                    file://node_modules/busboy/LICENSE;md5=df3ad145c2acbfc4f246fa834a6675c7 \
                    file://node_modules/bytes/LICENSE;md5=013e95467eddb048f19a6f5b42820f86 \
                    file://node_modules/cacheable-lookup/LICENSE;md5=23a0ab677f942ddc394168925c5a9328 \
                    file://node_modules/call-bind-apply-helpers/LICENSE;md5=8fe23ea421aaf9f9d687709f6a6a09b7 \
                    file://node_modules/call-bound/LICENSE;md5=8fe23ea421aaf9f9d687709f6a6a09b7 \
                    file://node_modules/cheerio-select/LICENSE;md5=d5b9cb3bc7f6ffd7bea8661f30447c11 \
                    file://node_modules/cheerio/LICENSE;md5=476b795003456b2ff8c5a905d5829955 \
                    file://node_modules/chownr/LICENSE.md;md5=add98d83942d5809bc719262ae40f4ce \
                    file://node_modules/cli-table/LICENSE;md5=7426c3e07cd555a7113d8e4740f8bf6a \
                    file://node_modules/clone/LICENSE;md5=411e33109fa516d190d232100fdc7f8e \
                    file://node_modules/color-convert/LICENSE;md5=9bdadfc9fbb3ab8d5a6d591bdbd52811 \
                    file://node_modules/color-name/LICENSE;md5=d301869b39e08b33665b7c4f16b8e41d \
                    file://node_modules/colors/MIT-LICENSE.txt;md5=5bc6c72caa0dcc082d24a52a6ae12112 \
                    file://node_modules/combined-stream/License;md5=5270b4ddb6700d0a820e6d066744589c \
                    file://node_modules/commist/LICENSE;md5=9d6c3a74d018cc8b3379ce581bcd28ab \
                    file://node_modules/concat-stream/LICENSE;md5=3ad90c134f824ddfcea611ee1fa567a8 \
                    file://node_modules/concat-stream/node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
                    file://node_modules/content-disposition/LICENSE;md5=13babc4f212ce635d68da544339c962b \
                    file://node_modules/content-disposition/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/content-type/LICENSE;md5=f4b767f006864f81a4901347fe4efdab \
                    file://node_modules/cookie-parser/LICENSE;md5=720bd7b9472a2297cd6820c73c71cf3e \
                    file://node_modules/cookie/LICENSE;md5=bc85b43b6f963e8ab3f88e63628448ca \
                    file://node_modules/core-util-is/LICENSE;md5=6126e36127d20ec0e2f637204a5c68ff \
                    file://node_modules/cors/LICENSE;md5=947eb5e695dade432a500b12c510de85 \
                    file://node_modules/cronosjs/LICENSE;md5=364202e8ebc58122042346798591bff7 \
                    file://node_modules/cross-spawn/LICENSE;md5=6046ffd2c9edcd9052bb4dd794d12f95 \
                    file://node_modules/css-select/LICENSE;md5=d5b9cb3bc7f6ffd7bea8661f30447c11 \
                    file://node_modules/css-what/LICENSE;md5=d5b9cb3bc7f6ffd7bea8661f30447c11 \
                    file://node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/decompress-response/license;md5=d5f2a6dd0192dcc7c833e50bb9017337 \
                    file://node_modules/decompress-response/node_modules/mimic-response/license;md5=d5f2a6dd0192dcc7c833e50bb9017337 \
                    file://node_modules/defer-to-connect/LICENSE;md5=78fd36a7284eb85369521bcb6e863186 \
                    file://node_modules/delayed-stream/License;md5=5270b4ddb6700d0a820e6d066744589c \
                    file://node_modules/denque/LICENSE;md5=f49b524d140e2dcf1b437d9185172531 \
                    file://node_modules/depd/LICENSE;md5=ebc30494fd072dc98368da73e1821715 \
                    file://node_modules/destroy/LICENSE;md5=d5eb22cf6cc99e645b98b28ee3503ddf \
                    file://node_modules/dom-serializer/LICENSE;md5=ba3390a22fe1d127f3522ac8ef1bd1a0 \
                    file://node_modules/domelementtype/LICENSE;md5=d5b9cb3bc7f6ffd7bea8661f30447c11 \
                    file://node_modules/domhandler/LICENSE;md5=d5b9cb3bc7f6ffd7bea8661f30447c11 \
                    file://node_modules/domutils/LICENSE;md5=d5b9cb3bc7f6ffd7bea8661f30447c11 \
                    file://node_modules/dunder-proto/LICENSE;md5=a5b1dd92a77a6632ebcc7425b08e9078 \
                    file://node_modules/ee-first/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/emoji-regex/LICENSE-MIT.txt;md5=ee9bd8b835cfcd512dd644540dd96987 \
                    file://node_modules/encodeurl/LICENSE;md5=272621efa0ff4f18a73221e49ab60654 \
                    file://node_modules/enquirer/LICENSE;md5=62927f9e287cbc1dbddd9c8f208b7cdb \
                    file://node_modules/entities/LICENSE;md5=d5b9cb3bc7f6ffd7bea8661f30447c11 \
                    file://node_modules/es-define-property/LICENSE;md5=8fe23ea421aaf9f9d687709f6a6a09b7 \
                    file://node_modules/es-errors/LICENSE;md5=8fe23ea421aaf9f9d687709f6a6a09b7 \
                    file://node_modules/es-object-atoms/LICENSE;md5=8fe23ea421aaf9f9d687709f6a6a09b7 \
                    file://node_modules/escape-html/LICENSE;md5=f8746101546eeb9e4f6de64bb8bdf595 \
                    file://node_modules/etag/LICENSE;md5=6e8686b7b13dd7ac8733645a81842c4a \
                    file://node_modules/event-target-shim/LICENSE;md5=893385a31dda2493704bc7f39bc976a0 \
                    file://node_modules/events/LICENSE;md5=d6ec4b5e129a1d757b41126ba3934078 \
                    file://node_modules/express-session/LICENSE;md5=23efdb85883c5cc9b6cc5b0456666a2b \
                    file://node_modules/express-session/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/express/LICENSE;md5=5513c00a5c36cd361da863dd9aa8875d \
                    file://node_modules/express/node_modules/cookie/LICENSE;md5=bc85b43b6f963e8ab3f88e63628448ca \
                    file://node_modules/express/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/fast-deep-equal/LICENSE;md5=ea87ade09b9e6da4f2e47904a4ee137b \
                    file://node_modules/fast-unique-numbers/LICENSE;md5=9c14a4d0f073df3cc102a3e38460f69d \
                    file://node_modules/fast-uri/LICENSE;md5=c67d2a4a86daf7422c31d6d6d63b2bb0 \
                    file://node_modules/finalhandler/LICENSE;md5=462b10b32bb9175b97944aabef4aa171 \
                    file://node_modules/follow-redirects/LICENSE;md5=2913574e921aefe1275cd5864b4f9b66 \
                    file://node_modules/foreground-child/LICENSE;md5=0069d577f409666fc7a8e879eb49c164 \
                    file://node_modules/form-data-encoder/license;md5=786532abfe383df8c1fdafb07578f5f6 \
                    file://node_modules/form-data/License;md5=7aa505292e2636a9e59d4d3f258f4819 \
                    file://node_modules/forwarded/LICENSE;md5=13babc4f212ce635d68da544339c962b \
                    file://node_modules/fresh/LICENSE;md5=373c2cf0978b37e434394a43b4cbbdb4 \
                    file://node_modules/fs-extra/LICENSE;md5=ea817882455c03503f7d014a8f54f095 \
                    file://node_modules/function-bind/LICENSE;md5=e7417c1a8ad83f88bcac21ad440d48b2 \
                    file://node_modules/get-intrinsic/LICENSE;md5=0eb2c73daa0ecf037cbdf3d0bb0c98d5 \
                    file://node_modules/get-proto/LICENSE;md5=a0b3a4562fb57e50242fb66b24fd2cdf \
                    file://node_modules/get-stream/license;md5=d5f2a6dd0192dcc7c833e50bb9017337 \
                    file://node_modules/glob/LICENSE;md5=72480347f4e847c91bbe6207b7567338 \
                    file://node_modules/gopd/LICENSE;md5=8478c87d16770f6d32a4578c475d3930 \
                    file://node_modules/got/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/graceful-fs/LICENSE;md5=163972d49c2f7a3d3b687aeb48e9e3c9 \
                    file://node_modules/has-symbols/LICENSE;md5=afee57a289508ed4df3456667778aaf6 \
                    file://node_modules/hash-sum/license;md5=06049b6eb5e43aafd8fe7c733d033646 \
                    file://node_modules/hasown/LICENSE;md5=19283ee92f78c91154834571c1f05a94 \
                    file://node_modules/help-me/LICENSE;md5=f15902492d54d5b2ec098c781019c6dd \
                    file://node_modules/hpagent/LICENSE;md5=6b1a33a7ee2baee18174a3db1ec2138f \
                    file://node_modules/htmlparser2/LICENSE;md5=10e03952c97f225d4229d7524619eb7f \
                    file://node_modules/http-cache-semantics/LICENSE;md5=7b7cd412797b9e24e3c58eff96661bf9 \
                    file://node_modules/http-errors/LICENSE;md5=607209623abfcc77b9098f71a0ef52f9 \
                    file://node_modules/http2-wrapper/LICENSE;md5=78fd36a7284eb85369521bcb6e863186 \
                    file://node_modules/https-proxy-agent/node_modules/debug/LICENSE;md5=d85a365580888e9ee0a01fb53e8e9bf0 \
                    file://node_modules/https-proxy-agent/node_modules/ms/license.md;md5=2b8bc52ae6b7ba58e1629deabd53986f \
                    file://node_modules/i18next/LICENSE;md5=5104d4d3d0668e37c3e33810f72e4f32 \
                    file://node_modules/iconv-lite/LICENSE;md5=f942263d98f0d75e0e0101884e86261d \
                    file://node_modules/ieee754/LICENSE;md5=56c3be003027d64d24ca6b69a2612f2f \
                    file://node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/ipaddr.js/LICENSE;md5=88f60a4b6e44cb849b5d907a7664c0ef \
                    file://node_modules/is-fullwidth-code-point/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/is-utf8/LICENSE;md5=10d1495ba46609e55e586ab71fa81f45 \
                    file://node_modules/isexe/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/jackspeak/LICENSE.md;md5=9f6dc78e3d8215fcb9da78e5ab9e29af \
                    file://node_modules/js-sdsl/LICENSE;md5=767604b1ed08213fd284407d38e9eec2 \
                    file://node_modules/js-yaml/LICENSE;md5=effd621a9bf5d72d6a7e6ef819bf3afb \
                    file://node_modules/json-buffer/LICENSE;md5=f26ea3f2a31273ebd199d933804f5e8b \
                    file://node_modules/json-schema-traverse/LICENSE;md5=ea87ade09b9e6da4f2e47904a4ee137b \
                    file://node_modules/json-stringify-safe/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/jsonata/LICENSE;md5=0a2fefbb55a84675607e8efd57183e99 \
                    file://node_modules/jsonfile/LICENSE;md5=423f377ade95936f6fe009b1c137bfdb \
                    file://node_modules/lodash.clonedeep/LICENSE;md5=a3b2b7770df62392c164de4001b59f8f \
                    file://node_modules/lowercase-keys/license;md5=d5f2a6dd0192dcc7c833e50bb9017337 \
                    file://node_modules/lru-cache/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/math-intrinsics/LICENSE;md5=a5b1dd92a77a6632ebcc7425b08e9078 \
                    file://node_modules/media-typer/LICENSE;md5=13babc4f212ce635d68da544339c962b \
                    file://node_modules/memorystore/LICENSE;md5=3c97a7f1928df131f083f488a42c41b7 \
                    file://node_modules/memorystore/node_modules/debug/LICENSE;md5=d85a365580888e9ee0a01fb53e8e9bf0 \
                    file://node_modules/memorystore/node_modules/ms/license.md;md5=2b8bc52ae6b7ba58e1629deabd53986f \
                    file://node_modules/merge-descriptors/LICENSE;md5=aaf57ba8c5c9bf256fea7e943991a81a \
                    file://node_modules/methods/LICENSE;md5=c16a7dd9f946172f07086576d135d9d3 \
                    file://node_modules/mime-db/LICENSE;md5=175b28b58359f8b4a969c9ab7c828445 \
                    file://node_modules/mime-types/LICENSE;md5=bf1f9ad1e2e1d507aef4883fff7103de \
                    file://node_modules/mime/LICENSE;md5=8e8ea2ad138ce468f8570a0edbadea65 \
                    file://node_modules/mimic-response/license;md5=d5f2a6dd0192dcc7c833e50bb9017337 \
                    file://node_modules/minimatch/LICENSE;md5=8b78835ea26f80c9067a0e80a294d926 \
                    file://node_modules/minimist/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/minipass/LICENSE;md5=5f114ac709a085d123e16c1e6363793f \
                    file://node_modules/minizlib/LICENSE;md5=fbc1f0c0579bf771702bde788c59a319 \
                    file://node_modules/mkdirp/LICENSE;md5=b2d989bc186e7f6b418a5fdd5cc0b56b \
                    file://node_modules/moment-timezone/LICENSE;md5=f51212467d7a94e1583a4cff9492bd80 \
                    file://node_modules/moment/LICENSE;md5=397bb5fedab22612d8d69f1458a9321e \
                    file://node_modules/mqtt-packet/LICENSE.md;md5=622e77e45833bb4f785aebc7e41c0bdb \
                    file://node_modules/mqtt-packet/node_modules/debug/LICENSE;md5=d85a365580888e9ee0a01fb53e8e9bf0 \
                    file://node_modules/mqtt-packet/node_modules/ms/license.md;md5=2b8bc52ae6b7ba58e1629deabd53986f \
                    file://node_modules/mqtt/LICENSE.md;md5=261aa46f11e9a7bdbea1dea7eb8bcb6c \
                    file://node_modules/mqtt/node_modules/debug/LICENSE;md5=d85a365580888e9ee0a01fb53e8e9bf0 \
                    file://node_modules/mqtt/node_modules/lru-cache/LICENSE;md5=28b53f8938bb3cf7c37ed8ac5e7d233e \
                    file://node_modules/mqtt/node_modules/ms/license.md;md5=2b8bc52ae6b7ba58e1629deabd53986f \
                    file://node_modules/mqtt/node_modules/ws/LICENSE;md5=7a4bd929a6c0e6951846d75e53fc9f51 \
                    file://node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/multer/LICENSE;md5=039580279923334e9eaeb656c54e6039 \
                    file://node_modules/multer/node_modules/concat-stream/LICENSE;md5=3ad90c134f824ddfcea611ee1fa567a8 \
                    file://node_modules/multer/node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
                    file://node_modules/multer/node_modules/string_decoder/LICENSE;md5=14af51f8c0a6c6e400b53e18c6e5f85c \
                    file://node_modules/mustache/LICENSE;md5=33fa3c7f27611cfb1191e5aa2bb107b1 \
                    file://node_modules/mute-stream/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/negotiator/LICENSE;md5=6417a862a5e35c17c904d9dda2cbd499 \
                    file://node_modules/node-red-admin/LICENSE;md5=2ee41112a44fe7014dce33e26468ba93 \
                    file://node_modules/node-watch/LICENSE;md5=45f58283bc015e07b9cd1378c52bec29 \
                    file://node_modules/nopt/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/normalize-url/license;md5=d5f2a6dd0192dcc7c833e50bb9017337 \
                    file://node_modules/nth-check/LICENSE;md5=d5b9cb3bc7f6ffd7bea8661f30447c11 \
                    file://node_modules/number-allocator/LICENSE;md5=ceff88c0907db57b52716bb46eeaaa2a \
                    file://node_modules/number-allocator/node_modules/debug/LICENSE;md5=d85a365580888e9ee0a01fb53e8e9bf0 \
                    file://node_modules/number-allocator/node_modules/ms/license.md;md5=2b8bc52ae6b7ba58e1629deabd53986f \
                    file://node_modules/oauth2orize/LICENSE;md5=a8bb4f4cb5363bb836b78892cd0afc31 \
                    file://node_modules/object-assign/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/object-inspect/LICENSE;md5=288162f1d1bfa064f127f2b42d2a656f \
                    file://node_modules/on-finished/LICENSE;md5=1b1f7f9cec194121fdf616b971df7a7b \
                    file://node_modules/on-headers/LICENSE;md5=c6e0ce1e688c5ff16db06b7259e9cd20 \
                    file://node_modules/p-cancelable/license;md5=d5f2a6dd0192dcc7c833e50bb9017337 \
                    file://node_modules/package-json-from-dist/LICENSE.md;md5=add98d83942d5809bc719262ae40f4ce \
                    file://node_modules/parse5-htmlparser2-tree-adapter/LICENSE;md5=179850e04995d6fceaf64f2dd2a851b0 \
                    file://node_modules/parse5/LICENSE;md5=179850e04995d6fceaf64f2dd2a851b0 \
                    file://node_modules/parseurl/LICENSE;md5=e7842ed4f188e53e53c3e8d9c4807e89 \
                    file://node_modules/passport-http-bearer/LICENSE;md5=f694b9c022a5bf0f2c3976a047fed39c \
                    file://node_modules/passport-oauth2-client-password/LICENSE;md5=95ca2874231d1b4d06ca94c35aa604f7 \
                    file://node_modules/passport-strategy/LICENSE;md5=f694b9c022a5bf0f2c3976a047fed39c \
                    file://node_modules/passport/LICENSE;md5=c938fd0af4a4585702899b6a50a928f2 \
                    file://node_modules/path-key/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/path-scurry/LICENSE.md;md5=95e9f67f2840df3a3a09a77ef3aea34b \
                    file://node_modules/path-scurry/node_modules/lru-cache/LICENSE;md5=28b53f8938bb3cf7c37ed8ac5e7d233e \
                    file://node_modules/path-to-regexp/LICENSE;md5=44088ba57cb871a58add36ce51b8de08 \
                    file://node_modules/process-nextick-args/license.md;md5=216769dac98a78ec088ee7cc6fad1dfa \
                    file://node_modules/process/LICENSE;md5=460a1c62fb575fc77668890ec8d03d0b \
                    file://node_modules/proxy-addr/LICENSE;md5=6e8686b7b13dd7ac8733645a81842c4a \
                    file://node_modules/proxy-from-env/LICENSE;md5=1dd031451af4b09bc10b26b0c06141e3 \
                    file://node_modules/pseudomap/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/qs/LICENSE.md;md5=b289135779dd930509ae81e6041690c0 \
                    file://node_modules/quick-lru/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/random-bytes/LICENSE;md5=65cf5baa33cf259f107bbfc965d9f8a0 \
                    file://node_modules/range-parser/LICENSE;md5=d4246fb961a4f121eef5ffca47f0b010 \
                    file://node_modules/raw-body/LICENSE;md5=f22163d3bc6b4bc1bbbdf654fe30af5b \
                    file://node_modules/read/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
                    file://node_modules/regenerator-runtime/LICENSE;md5=57a79768a3b1e4d0f3a3787048a96356 \
                    file://node_modules/reinterval/LICENSE;md5=c65ef22a386436c433298ca42418c200 \
                    file://node_modules/require-from-string/license;md5=be72c3ad86c1c4e9578a1945b082b17d \
                    file://node_modules/resolve-alpn/LICENSE;md5=f3d086f7c83cdc609b9f5d6057d7c1e4 \
                    file://node_modules/responselike/license;md5=7e0cad6f2a5f83edfe7ec84891554222 \
                    file://node_modules/rfdc/LICENSE;md5=fc2ea1f4c58a804909742c8eadede5ea \
                    file://node_modules/rimraf/LICENSE;md5=8b78835ea26f80c9067a0e80a294d926 \
                    file://node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/safer-buffer/LICENSE;md5=3baebc2a17b8f5bff04882cd0dc0f76e \
                    file://node_modules/sax/LICENSE;md5=5f49410228c16917dacc5eab921004cb \
                    file://node_modules/semver/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/send/LICENSE;md5=5f1a8369a899b128aaa8a59d60d00b40 \
                    file://node_modules/send/node_modules/encodeurl/LICENSE;md5=272621efa0ff4f18a73221e49ab60654 \
                    file://node_modules/send/node_modules/mime/LICENSE;md5=8e8ea2ad138ce468f8570a0edbadea65 \
                    file://node_modules/send/node_modules/ms/license.md;md5=2b8bc52ae6b7ba58e1629deabd53986f \
                    file://node_modules/serve-static/LICENSE;md5=27b1707520b14d0bc890f4e75cd387b0 \
                    file://node_modules/setprototypeof/LICENSE;md5=4846f1626304c2c0f806a539bbc7d54a \
                    file://node_modules/shebang-command/license;md5=05240cd20679544d6e90fcff746425bc \
                    file://node_modules/shebang-regex/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/side-channel-list/LICENSE;md5=8fe23ea421aaf9f9d687709f6a6a09b7 \
                    file://node_modules/side-channel-map/LICENSE;md5=8fe23ea421aaf9f9d687709f6a6a09b7 \
                    file://node_modules/side-channel-weakmap/LICENSE;md5=375dc7ca936a14e9c29418d5263bd066 \
                    file://node_modules/side-channel/LICENSE;md5=375dc7ca936a14e9c29418d5263bd066 \
                    file://node_modules/signal-exit/LICENSE.txt;md5=f04dc8bb8ec57c41ddd8ef51491862cb \
                    file://node_modules/split2/LICENSE;md5=a3b84061387696c9678867c878a6bbc3 \
                    file://node_modules/statuses/LICENSE;md5=36e2bc837ce69a98cc33a9e140d457e5 \
                    file://node_modules/streamsearch/LICENSE;md5=cbf7b3097b1484b7e6c118fc1d31f877 \
                    file://node_modules/string-width-cjs/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/string-width-cjs/node_modules/emoji-regex/LICENSE-MIT.txt;md5=ee9bd8b835cfcd512dd644540dd96987 \
                    file://node_modules/string-width/license;md5=d5f2a6dd0192dcc7c833e50bb9017337 \
                    file://node_modules/string-width/node_modules/ansi-regex/license;md5=d5f2a6dd0192dcc7c833e50bb9017337 \
                    file://node_modules/string-width/node_modules/strip-ansi/license;md5=d5f2a6dd0192dcc7c833e50bb9017337 \
                    file://node_modules/string_decoder/LICENSE;md5=14af51f8c0a6c6e400b53e18c6e5f85c \
                    file://node_modules/string_decoder/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/strip-ansi-cjs/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/strip-ansi/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/tar/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/tar/node_modules/mkdirp/LICENSE;md5=a60196c83bf81cd88a33680351c3a6f6 \
                    file://node_modules/tar/node_modules/yallist/LICENSE.md;md5=add98d83942d5809bc719262ae40f4ce \
                    file://node_modules/tldts-core/LICENSE;md5=6adc4bc57237e0d634e2629a1daa94f1 \
                    file://node_modules/tldts/LICENSE;md5=6adc4bc57237e0d634e2629a1daa94f1 \
                    file://node_modules/toidentifier/LICENSE;md5=1a261071a044d02eb6f2bb47f51a3502 \
                    file://node_modules/tough-cookie/LICENSE;md5=7189377a5215f1211b70cf2b9754841e \
                    file://node_modules/tslib/CopyrightNotice.txt;md5=cb391e9e435b114c07bee8f6754c4f98 \
                    file://node_modules/tslib/LICENSE.txt;md5=f938d99cba29007eeae26d80a9a4cfa6 \
                    file://node_modules/type-is/LICENSE;md5=0afd201e48c7d095454eed4ac1184e40 \
                    file://node_modules/type-is/node_modules/media-typer/LICENSE;md5=c6e0ce1e688c5ff16db06b7259e9cd20 \
                    file://node_modules/typedarray/LICENSE;md5=6085b70b74c7dcf7df4e955725e3153d \
                    file://node_modules/uglify-js/LICENSE;md5=00b45202695de5cd110bd3c2927a0da2 \
                    file://node_modules/uid-safe/LICENSE;md5=6a3e6caad2780f696f4884e98789e866 \
                    file://node_modules/uid2/LICENSE;md5=dd54d0741106ff4193bcecb833f6e350 \
                    file://node_modules/undici-types/LICENSE;md5=5809878683f4d0ea6781d9d18e6e6baa \
                    file://node_modules/universalify/LICENSE;md5=a734c6ad6e37a515025ac5e8e90ef786 \
                    file://node_modules/unpipe/LICENSE;md5=934ab86a8ab081ea0326add08d550739 \
                    file://node_modules/util-deprecate/LICENSE;md5=b7c99ef4b0f3ad9911a52219947f8cf0 \
                    file://node_modules/utils-merge/LICENSE;md5=1cf0906082187f374cb9a63c54eb782c \
                    file://node_modules/uuid/LICENSE.md;md5=353e680cdafd96bf30131cbb7b14a6e8 \
                    file://node_modules/vary/LICENSE;md5=13babc4f212ce635d68da544339c962b \
                    file://node_modules/which/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/worker-timers-broker/LICENSE;md5=a2d17a360a8ef9f1d5fbf1c6b77273a3 \
                    file://node_modules/worker-timers-worker/LICENSE;md5=a2d17a360a8ef9f1d5fbf1c6b77273a3 \
                    file://node_modules/worker-timers/LICENSE;md5=a2d17a360a8ef9f1d5fbf1c6b77273a3 \
                    file://node_modules/wrap-ansi-cjs/license;md5=d5f2a6dd0192dcc7c833e50bb9017337 \
                    file://node_modules/wrap-ansi-cjs/node_modules/ansi-styles/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/wrap-ansi-cjs/node_modules/emoji-regex/LICENSE-MIT.txt;md5=ee9bd8b835cfcd512dd644540dd96987 \
                    file://node_modules/wrap-ansi-cjs/node_modules/string-width/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/wrap-ansi/license;md5=d5f2a6dd0192dcc7c833e50bb9017337 \
                    file://node_modules/wrap-ansi/node_modules/ansi-regex/license;md5=d5f2a6dd0192dcc7c833e50bb9017337 \
                    file://node_modules/wrap-ansi/node_modules/strip-ansi/license;md5=d5f2a6dd0192dcc7c833e50bb9017337 \
                    file://node_modules/ws/LICENSE;md5=95833e8f03687308b0584a377b9e12b0 \
                    file://node_modules/xml2js/LICENSE;md5=d9fc599c8d9e6f8665063862aac66dfc \
                    file://node_modules/xmlbuilder/LICENSE;md5=f2836c06c74eca0f4565de06fe9900b0 \
                    file://node_modules/xtend/LICENSE;md5=66787c5cd698a0b30b358c7e30f500ca \
                    file://node_modules/yallist/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/agent-base/README.md;md5=dbe7cc0e18a5ea985d912037b4b52370 \
                    file://node_modules/boolbase/README.md;md5=48c1ef3558d25499a96a3d66baed5d9c \
                    file://node_modules/cacheable-request/README.md;md5=d6841ab539f9b15912a8f1ab3f724bd3 \
                    file://node_modules/cookie-signature/Readme.md;md5=57ae8b42de3dd0c1f22d5f4cf191e15a \
                    file://node_modules/eastasianwidth/README.md;md5=23d7429a66f9cf215a19ab6f62ca93d6 \
                    file://node_modules/express-session/node_modules/cookie-signature/Readme.md;md5=57ae8b42de3dd0c1f22d5f4cf191e15a \
                    file://node_modules/https-proxy-agent/README.md;md5=e12766dc96cd30a6103008d06c45ef01 \
                    file://node_modules/isarray/README.md;md5=e7424a48d45a2e04d52c15e786681063 \
                    file://node_modules/keyv/README.md;md5=db121f5e2f581330e048a72fad3c7c54 \
                    file://node_modules/pause/Readme.md;md5=01a259e8ee7455ffbf3042a40b34bf2a"

SRC_URI = " \
    npm://registry.npmjs.org/;package=node-red;version=${PV} \
    npmsw://${THISDIR}/${BPN}/npm-shrinkwrap.json \
    "

S = "${WORKDIR}/npm"

inherit npm

LICENSE:${PN} = "Apache-2.0"
LICENSE:${PN}-babel-runtime = "MIT"
LICENSE:${PN}-isaacs-cliui = "ISC & MIT"
LICENSE:${PN}-isaacs-cliui-ansi-regex = "Unknown"
LICENSE:${PN}-isaacs-cliui-strip-ansi = "Unknown"
LICENSE:${PN}-isaacs-fs-minipass = "ISC"
LICENSE:${PN}-node-red-editor-api = "Apache-2.0"
LICENSE:${PN}-node-red-editor-client = "Apache-2.0 & MIT & Unknown"
LICENSE:${PN}-node-red-nodes = "Apache-2.0"
LICENSE:${PN}-node-red-registry = "Apache-2.0"
LICENSE:${PN}-node-red-runtime = "Apache-2.0"
LICENSE:${PN}-node-red-util = "Apache-2.0"
LICENSE:${PN}-node-rs-bcrypt = "MIT"
LICENSE:${PN}-pkgjs-parseargs = "Apache-2.0"
LICENSE:${PN}-sindresorhus-is = "MIT"
LICENSE:${PN}-szmarczak-http-timer = "MIT"
LICENSE:${PN}-types-http-cache-semantics = "MIT"
LICENSE:${PN}-types-node = "MIT"
LICENSE:${PN}-types-readable-stream = "MIT"
LICENSE:${PN}-types-ws = "MIT"
LICENSE:${PN}-abbrev = "Unknown"
LICENSE:${PN}-abort-controller = "MIT"
LICENSE:${PN}-accepts = "MIT"
LICENSE:${PN}-acorn = "MIT"
LICENSE:${PN}-acorn-walk = "MIT"
LICENSE:${PN}-agent-base = "MIT & Unknown"
LICENSE:${PN}-agent-base-debug = "Unknown"
LICENSE:${PN}-agent-base-ms = "Unknown"
LICENSE:${PN}-ajv = "MIT"
LICENSE:${PN}-ansi-colors = "MIT"
LICENSE:${PN}-ansi-regex = "MIT"
LICENSE:${PN}-ansi-styles = "MIT"
LICENSE:${PN}-append-field = "MIT"
LICENSE:${PN}-argparse = "Unknown"
LICENSE:${PN}-array-flatten = "MIT"
LICENSE:${PN}-async-mutex = "MIT"
LICENSE:${PN}-asynckit = "MIT"
LICENSE:${PN}-axios = "MIT"
LICENSE:${PN}-balanced-match = "MIT"
LICENSE:${PN}-base64-js = "MIT"
LICENSE:${PN}-basic-auth = "MIT"
LICENSE:${PN}-bcryptjs = "Unknown"
LICENSE:${PN}-bl = "Unknown"
LICENSE:${PN}-body-parser = "MIT"
LICENSE:${PN}-body-parser-iconv-lite = "Unknown"
LICENSE:${PN}-body-parser-raw-body = "Unknown"
LICENSE:${PN}-boolbase = "Unknown"
LICENSE:${PN}-brace-expansion = "MIT"
LICENSE:${PN}-buffer = "MIT"
LICENSE:${PN}-buffer-from = "MIT"
LICENSE:${PN}-busboy = "MIT"
LICENSE:${PN}-bytes = "MIT"
LICENSE:${PN}-cacheable-lookup = "MIT"
LICENSE:${PN}-cacheable-request = "Unknown"
LICENSE:${PN}-call-bind-apply-helpers = "MIT"
LICENSE:${PN}-call-bound = "MIT"
LICENSE:${PN}-cheerio = "MIT"
LICENSE:${PN}-cheerio-select = "Unknown"
LICENSE:${PN}-chownr = "Unknown"
LICENSE:${PN}-cli-table = "MIT"
LICENSE:${PN}-clone = "MIT"
LICENSE:${PN}-color-convert = "MIT"
LICENSE:${PN}-color-name = "MIT"
LICENSE:${PN}-colors = "Unknown"
LICENSE:${PN}-combined-stream = "MIT"
LICENSE:${PN}-commist = "MIT"
LICENSE:${PN}-concat-stream = "MIT & Unknown"
LICENSE:${PN}-concat-stream-readable-stream = "Unknown"
LICENSE:${PN}-content-disposition = "MIT"
LICENSE:${PN}-content-disposition-safe-buffer = "Unknown"
LICENSE:${PN}-content-type = "MIT"
LICENSE:${PN}-cookie = "MIT"
LICENSE:${PN}-cookie-parser = "MIT"
LICENSE:${PN}-cookie-signature = "Unknown"
LICENSE:${PN}-core-util-is = "MIT"
LICENSE:${PN}-cors = "MIT"
LICENSE:${PN}-cronosjs = "ISC"
LICENSE:${PN}-cross-spawn = "MIT"
LICENSE:${PN}-css-select = "Unknown"
LICENSE:${PN}-css-what = "Unknown"
LICENSE:${PN}-debug = "MIT"
LICENSE:${PN}-decompress-response = "MIT"
LICENSE:${PN}-decompress-response-mimic-response = "Unknown"
LICENSE:${PN}-defer-to-connect = "MIT"
LICENSE:${PN}-delayed-stream = "MIT"
LICENSE:${PN}-denque = "Apache-2.0"
LICENSE:${PN}-depd = "MIT"
LICENSE:${PN}-destroy = "MIT"
LICENSE:${PN}-dom-serializer = "MIT"
LICENSE:${PN}-domelementtype = "Unknown"
LICENSE:${PN}-domhandler = "Unknown"
LICENSE:${PN}-domutils = "Unknown"
LICENSE:${PN}-dunder-proto = "MIT"
LICENSE:${PN}-eastasianwidth = "Unknown"
LICENSE:${PN}-ee-first = "MIT"
LICENSE:${PN}-emoji-regex = "MIT"
LICENSE:${PN}-encodeurl = "MIT"
LICENSE:${PN}-enquirer = "MIT"
LICENSE:${PN}-entities = "Unknown"
LICENSE:${PN}-es-define-property = "MIT"
LICENSE:${PN}-es-errors = "MIT"
LICENSE:${PN}-es-object-atoms = "MIT"
LICENSE:${PN}-escape-html = "MIT"
LICENSE:${PN}-etag = "MIT"
LICENSE:${PN}-event-target-shim = "MIT"
LICENSE:${PN}-events = "MIT"
LICENSE:${PN}-express = "MIT"
LICENSE:${PN}-express-session = "MIT & Unknown"
LICENSE:${PN}-express-session-cookie-signature = "Unknown"
LICENSE:${PN}-express-session-safe-buffer = "Unknown"
LICENSE:${PN}-express-cookie = "Unknown"
LICENSE:${PN}-express-safe-buffer = "Unknown"
LICENSE:${PN}-fast-deep-equal = "MIT"
LICENSE:${PN}-fast-unique-numbers = "MIT"
LICENSE:${PN}-fast-uri = "Unknown"
LICENSE:${PN}-finalhandler = "MIT"
LICENSE:${PN}-follow-redirects = "MIT"
LICENSE:${PN}-foreground-child = "ISC"
LICENSE:${PN}-form-data = "MIT"
LICENSE:${PN}-form-data-encoder = "MIT"
LICENSE:${PN}-forwarded = "MIT"
LICENSE:${PN}-fresh = "MIT"
LICENSE:${PN}-fs-extra = "MIT"
LICENSE:${PN}-function-bind = "MIT"
LICENSE:${PN}-get-intrinsic = "MIT"
LICENSE:${PN}-get-proto = "MIT"
LICENSE:${PN}-get-stream = "MIT"
LICENSE:${PN}-glob = "ISC"
LICENSE:${PN}-gopd = "MIT"
LICENSE:${PN}-got = "MIT"
LICENSE:${PN}-graceful-fs = "ISC"
LICENSE:${PN}-has-symbols = "MIT"
LICENSE:${PN}-hash-sum = "MIT"
LICENSE:${PN}-hasown = "MIT"
LICENSE:${PN}-help-me = "MIT"
LICENSE:${PN}-hpagent = "MIT"
LICENSE:${PN}-htmlparser2 = "MIT"
LICENSE:${PN}-http-cache-semantics = "BSD-2-Clause"
LICENSE:${PN}-http-errors = "MIT"
LICENSE:${PN}-http2-wrapper = "MIT"
LICENSE:${PN}-https-proxy-agent = "MIT & Unknown"
LICENSE:${PN}-https-proxy-agent-debug = "Unknown"
LICENSE:${PN}-https-proxy-agent-ms = "Unknown"
LICENSE:${PN}-i18next = "MIT"
LICENSE:${PN}-iconv-lite = "MIT"
LICENSE:${PN}-ieee754 = "BSD-3-Clause"
LICENSE:${PN}-inherits = "ISC"
LICENSE:${PN}-ipaddrjs = "MIT"
LICENSE:${PN}-is-fullwidth-code-point = "MIT"
LICENSE:${PN}-is-utf8 = "MIT"
LICENSE:${PN}-isarray = "Unknown"
LICENSE:${PN}-isexe = "ISC"
LICENSE:${PN}-jackspeak = "Unknown"
LICENSE:${PN}-js-sdsl = "MIT"
LICENSE:${PN}-js-yaml = "MIT"
LICENSE:${PN}-json-buffer = "MIT"
LICENSE:${PN}-json-schema-traverse = "MIT"
LICENSE:${PN}-json-stringify-safe = "ISC"
LICENSE:${PN}-jsonata = "MIT"
LICENSE:${PN}-jsonfile = "MIT"
LICENSE:${PN}-keyv = "Unknown"
LICENSE:${PN}-lodashclonedeep = "Unknown"
LICENSE:${PN}-lowercase-keys = "MIT"
LICENSE:${PN}-lru-cache = "ISC"
LICENSE:${PN}-math-intrinsics = "MIT"
LICENSE:${PN}-media-typer = "MIT"
LICENSE:${PN}-memorystore = "MIT"
LICENSE:${PN}-memorystore-debug = "Unknown"
LICENSE:${PN}-memorystore-ms = "Unknown"
LICENSE:${PN}-merge-descriptors = "MIT"
LICENSE:${PN}-methods = "MIT"
LICENSE:${PN}-mime = "MIT"
LICENSE:${PN}-mime-db = "MIT"
LICENSE:${PN}-mime-types = "MIT"
LICENSE:${PN}-mimic-response = "MIT"
LICENSE:${PN}-minimatch = "ISC"
LICENSE:${PN}-minimist = "MIT"
LICENSE:${PN}-minipass = "ISC"
LICENSE:${PN}-minizlib = "Unknown"
LICENSE:${PN}-mkdirp = "MIT"
LICENSE:${PN}-moment = "MIT"
LICENSE:${PN}-moment-timezone = "MIT"
LICENSE:${PN}-mqtt = "ISC & MIT & Unknown"
LICENSE:${PN}-mqtt-packet = "MIT & Unknown"
LICENSE:${PN}-mqtt-packet-debug = "Unknown"
LICENSE:${PN}-mqtt-packet-ms = "Unknown"
LICENSE:${PN}-mqtt-debug = "Unknown"
LICENSE:${PN}-mqtt-lru-cache = "Unknown"
LICENSE:${PN}-mqtt-ms = "Unknown"
LICENSE:${PN}-mqtt-ws = "Unknown"
LICENSE:${PN}-ms = "MIT"
LICENSE:${PN}-multer = "MIT & Unknown"
LICENSE:${PN}-multer-concat-stream = "Unknown"
LICENSE:${PN}-multer-readable-stream = "Unknown"
LICENSE:${PN}-multer-stringdecoder = "Unknown"
LICENSE:${PN}-mustache = "MIT"
LICENSE:${PN}-mute-stream = "ISC"
LICENSE:${PN}-negotiator = "MIT"
LICENSE:${PN}-node-red-admin = "Apache-2.0"
LICENSE:${PN}-node-watch = "MIT"
LICENSE:${PN}-nopt = "ISC"
LICENSE:${PN}-normalize-url = "MIT"
LICENSE:${PN}-nth-check = "Unknown"
LICENSE:${PN}-number-allocator = "MIT"
LICENSE:${PN}-number-allocator-debug = "Unknown"
LICENSE:${PN}-number-allocator-ms = "Unknown"
LICENSE:${PN}-oauth2orize = "MIT"
LICENSE:${PN}-object-assign = "MIT"
LICENSE:${PN}-object-inspect = "MIT"
LICENSE:${PN}-on-finished = "MIT"
LICENSE:${PN}-on-headers = "MIT"
LICENSE:${PN}-p-cancelable = "MIT"
LICENSE:${PN}-package-json-from-dist = "Unknown"
LICENSE:${PN}-parse5 = "MIT"
LICENSE:${PN}-parse5-htmlparser2-tree-adapter = "MIT"
LICENSE:${PN}-parseurl = "MIT"
LICENSE:${PN}-passport = "MIT"
LICENSE:${PN}-passport-http-bearer = "MIT"
LICENSE:${PN}-passport-oauth2-client-password = "MIT"
LICENSE:${PN}-passport-strategy = "MIT"
LICENSE:${PN}-path-key = "MIT"
LICENSE:${PN}-path-scurry = "BlueOak-1.0.0 & ISC"
LICENSE:${PN}-path-scurry-lru-cache = "Unknown"
LICENSE:${PN}-path-to-regexp = "MIT"
LICENSE:${PN}-pause = "Unknown"
LICENSE:${PN}-process = "MIT"
LICENSE:${PN}-process-nextick-args = "MIT"
LICENSE:${PN}-proxy-addr = "MIT"
LICENSE:${PN}-proxy-from-env = "MIT"
LICENSE:${PN}-pseudomap = "ISC"
LICENSE:${PN}-qs = "BSD-3-Clause"
LICENSE:${PN}-quick-lru = "MIT"
LICENSE:${PN}-random-bytes = "MIT"
LICENSE:${PN}-range-parser = "MIT"
LICENSE:${PN}-raw-body = "MIT"
LICENSE:${PN}-read = "ISC"
LICENSE:${PN}-readable-stream = "Unknown"
LICENSE:${PN}-regenerator-runtime = "MIT"
LICENSE:${PN}-reinterval = "MIT"
LICENSE:${PN}-require-from-string = "MIT"
LICENSE:${PN}-resolve-alpn = "MIT"
LICENSE:${PN}-responselike = "MIT"
LICENSE:${PN}-rfdc = "MIT"
LICENSE:${PN}-rimraf = "ISC"
LICENSE:${PN}-safe-buffer = "MIT"
LICENSE:${PN}-safer-buffer = "MIT"
LICENSE:${PN}-sax = "Unknown"
LICENSE:${PN}-semver = "ISC"
LICENSE:${PN}-send = "MIT"
LICENSE:${PN}-send-encodeurl = "Unknown"
LICENSE:${PN}-send-mime = "Unknown"
LICENSE:${PN}-send-ms = "Unknown"
LICENSE:${PN}-serve-static = "MIT"
LICENSE:${PN}-setprototypeof = "ISC"
LICENSE:${PN}-shebang-command = "MIT"
LICENSE:${PN}-shebang-regex = "MIT"
LICENSE:${PN}-side-channel = "MIT"
LICENSE:${PN}-side-channel-list = "MIT"
LICENSE:${PN}-side-channel-map = "MIT"
LICENSE:${PN}-side-channel-weakmap = "MIT"
LICENSE:${PN}-signal-exit = "ISC"
LICENSE:${PN}-split2 = "ISC"
LICENSE:${PN}-statuses = "MIT"
LICENSE:${PN}-streamsearch = "MIT"
LICENSE:${PN}-stringdecoder = "MIT & Unknown"
LICENSE:${PN}-stringdecoder-safe-buffer = "Unknown"
LICENSE:${PN}-string-width = "MIT"
LICENSE:${PN}-string-width-cjs = "MIT"
LICENSE:${PN}-string-width-cjs-emoji-regex = "Unknown"
LICENSE:${PN}-string-width-ansi-regex = "Unknown"
LICENSE:${PN}-string-width-strip-ansi = "Unknown"
LICENSE:${PN}-strip-ansi = "MIT"
LICENSE:${PN}-strip-ansi-cjs = "MIT"
LICENSE:${PN}-tar = "ISC & MIT & Unknown"
LICENSE:${PN}-tar-mkdirp = "Unknown"
LICENSE:${PN}-tar-yallist = "Unknown"
LICENSE:${PN}-tldts = "MIT"
LICENSE:${PN}-tldts-core = "MIT"
LICENSE:${PN}-toidentifier = "MIT"
LICENSE:${PN}-tough-cookie = "Unknown"
LICENSE:${PN}-tslib = "0BSD"
LICENSE:${PN}-type-is = "MIT"
LICENSE:${PN}-type-is-media-typer = "Unknown"
LICENSE:${PN}-typedarray = "Unknown"
LICENSE:${PN}-uglify-js = "BSD-2-Clause"
LICENSE:${PN}-uid-safe = "MIT"
LICENSE:${PN}-uid2 = "MIT"
LICENSE:${PN}-undici-types = "MIT"
LICENSE:${PN}-universalify = "MIT"
LICENSE:${PN}-unpipe = "MIT"
LICENSE:${PN}-util-deprecate = "MIT"
LICENSE:${PN}-utils-merge = "MIT"
LICENSE:${PN}-uuid = "MIT"
LICENSE:${PN}-vary = "MIT"
LICENSE:${PN}-which = "ISC"
LICENSE:${PN}-worker-timers = "MIT"
LICENSE:${PN}-worker-timers-broker = "MIT"
LICENSE:${PN}-worker-timers-worker = "MIT"
LICENSE:${PN}-wrap-ansi = "MIT"
LICENSE:${PN}-wrap-ansi-cjs = "MIT"
LICENSE:${PN}-wrap-ansi-cjs-ansi-styles = "Unknown"
LICENSE:${PN}-wrap-ansi-cjs-emoji-regex = "Unknown"
LICENSE:${PN}-wrap-ansi-cjs-string-width = "Unknown"
LICENSE:${PN}-wrap-ansi-ansi-regex = "Unknown"
LICENSE:${PN}-wrap-ansi-strip-ansi = "Unknown"
LICENSE:${PN}-ws = "MIT"
LICENSE:${PN}-xml2js = "MIT"
LICENSE:${PN}-xmlbuilder = "MIT"
LICENSE:${PN}-xtend = "MIT"
LICENSE:${PN}-yallist = "ISC"
